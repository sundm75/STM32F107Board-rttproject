# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\..\..\..\rt-thread\rt-thread\components\net\lwip-2.0.2\src\include\netif; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\rt-thread\rt-thread\libcpu\arm\common; ..\..\..\..\..\rt-thread\rt-thread\components\net\lwip-2.0.2\src\include\posix; ..\..\..\..\..\rt-thread\rt-thread\components\dfs\include; ..\..\..\..\..\rt-thread\rt-thread\components\dfs\filesystems\elmfat; ..\..\..\..\..\rt-thread\rt-thread\components\CMSIS\Include; ..\..\..\..\..\rt-thread\rt-thread\include; .; ..\..\..\..\..\rt-thread\rt-thread\components\drivers\include; applications; ..\..\..\..\..\rt-thread\rt-thread\components\net\lwip-2.0.2\src\include\ipv4; ..\..\..\..\..\rt-thread\rt-thread\components\finsh; ..\..\..\..\..\rt-thread\rt-thread\components\drivers\spi; ..\..\..\..\..\rt-thread\rt-thread\components\net\lwip-2.0.2\src\include; ..\..\..\..\..\rt-thread\rt-thread\components\net\lwip-2.0.2\src\arch\include; ..\..\..\..\..\rt-thread\rt-thread\libcpu\arm\cortex-m3; ..\..\..\..\..\rt-thread\rt-thread\components\net\lwip-2.0.2\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: stm32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCOptLevel: 3
  group STM32_StdPeriph
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group Drivers
    ../../drivers/: CommonString.c GPRSIO.c I2C.c I2C_ee.c RS485.c RTC.c adc.c board.c calendar.c can.c candevice.c date.c gprs.c i2c_ee_dma.c key.c led.c msd.c platform.c rt_stm32f10x_spi.c serial.c spi_flash.c stm32_eth.c stm32f10x_it.c usart.c
  group Applications
    applications/: application.c startup.c
  group Kernel
    ../../../../../rt-thread/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M3
    ../../../../../rt-thread/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_iar.S
    ../../../../../rt-thread/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../../../rt-thread/rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../../../rt-thread/rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../../../../rt-thread/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group finsh
    ../../../../../rt-thread/rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group lwIP
    ../../../../../rt-thread/rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../../../../rt-thread/rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../rt-thread/rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../rt-thread/rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../../../rt-thread/rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
