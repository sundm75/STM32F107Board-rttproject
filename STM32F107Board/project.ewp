# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\RT-Thread_1.2.1\libcpu\arm\cortex-m3; ..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src\include\netif; ..\RT-Thread_1.2.1\libcpu\arm\common; Libraries\STM32F10x_StdPeriph_Driver\inc; ..\RT-Thread_1.2.1\components\finsh; ..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src\include; drivers; ..\RT-Thread_1.2.1\components\dfs; .; ..\RT-Thread_1.2.1\components\CMSIS\Include; applications; ..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src\include\ipv4; ..\RT-Thread_1.2.1\components\rtgui\include; ..\RT-Thread_1.2.1\components\dfs\include; ..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src\arch\include; ..\RT-Thread_1.2.1\components\drivers\include; ..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src; ..\RT-Thread_1.2.1\include; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: stm32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c setup.c startup.c ui_button.c
  group CORTEX-M3
    ../RT-Thread_1.2.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../RT-Thread_1.2.1/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../RT-Thread_1.2.1/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    drivers/: adc.c board.c calculator.c key.c lcd.c led.c msd.c platform.c rt_stm32f10x_spi.c serial.c stm32_eth.c stm32f10x_it.c touch_spi.c usart.c
  group Filesystem
    ../RT-Thread_1.2.1/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../RT-Thread_1.2.1/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../RT-Thread_1.2.1/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group gui_examples
    ../RT-Thread_1.2.1/components/guiexamples/examples/: demo_application.c demo_plot.c demo_view.c demo_view_animation.c demo_view_benchmark.c demo_view_bmp.c demo_view_box.c demo_view_buffer_animation.c demo_view_button.c demo_view_checkbox.c demo_view_combobox.c demo_view_dc.c demo_view_dc_buffer.c demo_view_digtube.c demo_view_edit.c demo_view_instrument_panel.c demo_view_label.c demo_view_listbox.c demo_view_listctrl.c demo_view_menu.c demo_view_mywidget.c demo_view_notebook.c demo_view_progressbar.c demo_view_radiobox.c demo_view_scrollbar.c demo_view_slider.c demo_view_textbox.c demo_view_ttf.c demo_view_window.c demo_xml.c mywidget.c
  group Kernel
    ../RT-Thread_1.2.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group LwIP
    ../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group RTGUI
    ../RT-Thread_1.2.1/components/rtgui/common/: asc12font.c asc16font.c blit.c color.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c font_hz_bmp.c font_hz_file.c framebuffer_driver.c hz12font.c hz16font.c image.c image_bmp.c image_container.c image_hdc.c image_jpg.c image_png.c image_xpm.c pixel_driver.c region.c rtgui_app.c rtgui_mv_model.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c
    ../RT-Thread_1.2.1/components/rtgui/widgets/: box.c button.c checkbox.c combobox.c container.c digfont.c digtube.c edit.c filelist_view.c groupbox.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c mv_view.c notebook.c panel.c plot.c plot_curve.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c textbox.c textview.c title.c widget.c window.c
    ../RT-Thread_1.2.1/components/rtgui/apps/: calibration.c
    ../RT-Thread_1.2.1/components/rtgui/server/: driver.c mouse.c server.c topwin.c
  group STM32_StdPeriph
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
