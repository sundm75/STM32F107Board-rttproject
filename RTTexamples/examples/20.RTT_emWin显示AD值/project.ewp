# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\drivers\emWin_Demo; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\RT-THREAD\components\finsh; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\RT-THREAD\components\drivers\spi; ..\..\Libraries\STemWinLibrary522\inc; .; ..\..\..\RT-THREAD\libcpu\arm\cortex-m3; applications; ..\..\..\RT-THREAD\components\drivers\include; ..\..\..\RT-THREAD\libcpu\arm\common; ..\..\..\RT-THREAD\include; ..\..\drivers\emWin_Config; ..\..\..\RT-THREAD\components\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: stm32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: adc1.c application.c GUIDEMO.c GUIDEMO_Graph.c startup.c testgui.c
  group CORTEX-M3
    ../../../RT-THREAD/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../RT-THREAD/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../RT-THREAD/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../../drivers/: board.c calendar.c can.c candevice.c CommonString.c date.c gprs.c GPRSIO.c I2C.c i2c_ee_dma.c key.c led.c platform.c RS485.c rt_stm32f10x_spi.c RTC.c serial.c spi_flash.c stm32f10x_it.c usart.c
  group emWin_Config
    ../../drivers/emWin_Config/: GUI_X_Touch_Analog.c GUIConf.c lcd.c LCDConf.c timer5.c TOUCH_Calibrate.c TOUCH_Sample.c touch_spi.c
  group emWin_Demo
    ../../drivers/emWin_Demo/: GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group emWin_library
    ../../Libraries/STemWinLibrary522/OS/: GUI_X.c
    ../../Libraries/STemWinLibrary522/Lib/: STemWin522_CM3_IAR.a
  group finsh
    ../../../RT-THREAD/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Kernel
    ../../../RT-THREAD/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group STM32_StdPeriph
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
