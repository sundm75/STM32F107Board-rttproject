# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: .;..\..\..\RT-Thread_1.2.1\components\CMSIS\Include;..\..\..\RT-Thread_1.2.1\components\drivers\include;..\..\..\RT-Thread_1.2.1\components\finsh;..\..\..\RT-Thread_1.2.1\include;..\..\..\RT-Thread_1.2.1\libcpu\arm\common;..\..\..\RT-Thread_1.2.1\libcpu\arm\cortex-m3;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\drivers;applications
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group STM32_StdPeriph
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Drivers
    ../../drivers/: ADC_Temperature.c CommonString.c GPRSIO.c I2C.c NRF24L01.c NRF24L012.c RS485.c RTC.c adc.c board.c calendar.c can.c candevice.c date.c gprs.c i2c_ee_dma.c key.c led.c msd.c platform.c rfspi.c serial.c spi_flash.c stm32f10x_it.c usart.c
  group Applications
    applications/: application.c startup.c
  group Kernel
    ../../../RT-Thread_1.2.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../../RT-Thread_1.2.1/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../../RT-Thread_1.2.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../../RT-Thread_1.2.1/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
