# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\..\RT-Thread_1.2.1\components\drivers\include; ..\..\..\RT-Thread_1.2.1\include; ..\..\..\RT-Thread_1.2.1\libcpu\arm\common; ..\..\..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src\include; ..\..\..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src\include\ipv4; ..\..\..\RT-Thread_1.2.1\components\dfs\include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\RT-Thread_1.2.1\components\net\freemodbus-v1.6.0\modbus\ascii; .; ..\..\..\RT-Thread_1.2.1\components\net\freemodbus-v1.6.0\modbus\tcp; ..\..\..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src\arch\include; ..\..\..\RT-Thread_1.2.1\components\net\freemodbus-v1.6.0\modbus\include; ..\..\..\RT-Thread_1.2.1\components\net\freemodbus-v1.6.0\modbus\rtu; ..\..\..\RT-Thread_1.2.1\libcpu\arm\cortex-m3; ..\..\..\RT-Thread_1.2.1\components\finsh; applications; ..\..\..\RT-Thread_1.2.1\components\net\freemodbus-v1.6.0\modbus\port; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\RT-Thread_1.2.1\components\CMSIS\Include; ..\..\..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src; ..\..\..\RT-Thread_1.2.1\components\net\lwip-1.4.1\src\include\netif; ..\..\..\RT-Thread_1.2.1\components\dfs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: stm32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c mbtest.c startup.c
  group CORTEX-M3
    ../../../RT-Thread_1.2.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../RT-Thread_1.2.1/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../RT-Thread_1.2.1/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../../drivers/: adc.c ADC_Temperature.c board.c calendar.c can.c date.c gprs.c GPRSIO.c I2C.c i2c_ee_dma.c key.c led.c msd.c platform.c RS485.c rt_stm32f10x_spi.c RTC.c serial.c spi_flash.c stm32_eth.c stm32f10x_it.c usart.c
  group Filesystem
    ../../../RT-Thread_1.2.1/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../RT-Thread_1.2.1/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../../../RT-Thread_1.2.1/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group FreeModbus
    ../../../RT-Thread_1.2.1/components/net/freemodbus-v1.6.0/modbus/: mb.c
    ../../../RT-Thread_1.2.1/components/net/freemodbus-v1.6.0/modbus/rtu/: mbcrc.c mbrtu.c
    ../../../RT-Thread_1.2.1/components/net/freemodbus-v1.6.0/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../../RT-Thread_1.2.1/components/net/freemodbus-v1.6.0/modbus/port/: port.c portevent.c portserial.c porttimer.c
  group Kernel
    ../../../RT-Thread_1.2.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group LwIP
    ../../../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../../../RT-Thread_1.2.1/components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group STM32_StdPeriph
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
