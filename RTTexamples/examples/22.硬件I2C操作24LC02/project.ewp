# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\..\RT-THREAD\components\dfs\filesystems\elmfat; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\include\ipv4; ..\..\..\RT-THREAD\components\finsh; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\RT-THREAD\components\dfs\include; ..\..\..\RT-THREAD\components\drivers\spi; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\arch\include; .; ..\..\..\RT-THREAD\libcpu\arm\cortex-m3; applications; STM32_CPAL_Driver\devices\stm32f10x; STM32_CPAL_Driver\inc; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\include; ..\..\..\RT-THREAD\components\drivers\include; ..\..\..\RT-THREAD\libcpu\arm\common; ..\..\..\RT-THREAD\include; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\include\netif; ..\..\..\RT-THREAD\components\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: stm32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\..\RT-THREAD\components\dfs\filesystems\elmfat; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\include\ipv4; ..\..\..\RT-THREAD\components\finsh; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\RT-THREAD\components\dfs\include; ..\..\..\RT-THREAD\components\drivers\spi; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\arch\include; .; ..\..\..\RT-THREAD\libcpu\arm\cortex-m3; applications; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\include; ..\..\..\RT-THREAD\components\drivers\include; ..\..\..\RT-THREAD\libcpu\arm\common; ..\..\..\RT-THREAD\include; ..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\include\netif; ..\..\..\RT-THREAD\components\CMSIS\Include
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c i2c_ee_test.c i2cdmatest.c i2ctest.c startup.c
  group CORTEX-M3
    ../../../RT-THREAD/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../RT-THREAD/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../RT-THREAD/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../../drivers/: adc.c board.c calendar.c can.c candevice.c CommonString.c date.c gprs.c GPRSIO.c I2C.c I2C_ee.c i2c_ee_dma.c key.c led.c msd.c platform.c RS485.c rt_stm32f10x_spi.c RTC.c serial.c spi_flash.c stm32_eth.c stm32f10x_it.c usart.c
  group Filesystem
    ../../../RT-THREAD/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../RT-THREAD/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../../../RT-THREAD/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Kernel
    ../../../RT-THREAD/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group LwIP
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group STM32_StdPeriph
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
