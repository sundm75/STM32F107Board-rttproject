<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Applications</name>
    <file>
      <name>$PROJ_DIR$\applications\application.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\applications\i2c_oled_test.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\applications\startup.c</name>
    </file>
  </group>
  <group>
    <name>CORTEX-M3</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\libcpu\arm\common\backtrace.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\libcpu\arm\cortex-m3\context_iar.S</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\libcpu\arm\cortex-m3\cpuport.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\libcpu\arm\common\div0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\libcpu\arm\common\showmem.c</name>
    </file>
  </group>
  <group>
    <name>DeviceDrivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\drivers\spi\spi_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\drivers\spi\spi_dev.c</name>
    </file>
  </group>
  <group>
    <name>Drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\calendar.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\candevice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\CommonString.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\date.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\gprs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\GPRSIO.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\I2C.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\I2C_ee.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\i2c_ee_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\msd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\platform.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\RS485.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\rt_stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\RTC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\serial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\spi_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\stm32_eth.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\drivers\usart.c</name>
    </file>
  </group>
  <group>
    <name>Filesystem</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\dfs\src\dfs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\dfs\filesystems\elmfat\dfs_elm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\dfs\src\dfs_file.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\dfs\src\dfs_fs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\dfs\src\dfs_posix.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\dfs\filesystems\elmfat\ff.c</name>
    </file>
  </group>
  <group>
    <name>finsh</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\cmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_compiler.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_error.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_heap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_node.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_ops.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_parser.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_token.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_var.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\finsh_vm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\shell.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\finsh\symbol.c</name>
    </file>
  </group>
  <group>
    <name>Kernel</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\device.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\idle.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\ipc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\irq.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\kservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\mempool.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\object.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\scheduler.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\thread.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\src\timer.c</name>
    </file>
  </group>
  <group>
    <name>LwIP</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\api\api_lib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\api\api_msg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\ipv4\autoip.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\def.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\dhcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\dns.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\api\err.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\netif\etharp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\netif\ethernetif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\ipv4\icmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\ipv4\igmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\ipv4\inet.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\ipv4\inet_chksum.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\ipv4\ip.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\ipv4\ip_addr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\ipv4\ip_frag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\memp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\api\netbuf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\api\netdb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\netif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\api\netifapi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\pbuf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\raw.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\netif\slipif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\api\sockets.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\stats.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\sys.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\arch\sys_arch.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\tcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\tcp_in.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\tcp_out.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\api\tcpip.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\timers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\core\udp.c</name>
    </file>
  </group>
  <group>
    <name>STM32_StdPeriph</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\startup_stm32f10x_cl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\system_stm32f10x.c</name>
    </file>
  </group>
</project>


