# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\drivers\emWin_Demo; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\RT-Thread_1.2.1\include; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\RT-Thread_1.2.1\components\dfs; ..\..\..\RT-Thread_1.2.1\components\CMSIS\Include; ..\..\..\RT-Thread_1.2.1\components\finsh; ..\..\..\RT-Thread_1.2.1\libcpu\arm\common; ..\..\Libraries\STemWinLibrary522\inc; .; applications; ..\..\..\RT-Thread_1.2.1\components\drivers\include; ..\..\drivers\emWin_Config; ..\..\..\RT-Thread_1.2.1\libcpu\arm\cortex-m3; ..\..\..\RT-Thread_1.2.1\components\dfs\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: stm32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c startup.c testgui.c
  group CORTEX-M3
    ../../../RT-Thread_1.2.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../RT-Thread_1.2.1/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../RT-Thread_1.2.1/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../../drivers/: adc.c ADC_Temperature.c board.c calendar.c can.c date.c gprs.c GPRSIO.c I2C.c i2c_ee_dma.c key.c led.c msd.c platform.c RS485.c rt_stm32f10x_spi.c RTC.c serial.c spi_flash.c stm32f10x_it.c usart.c
  group emWin_Config
    ../../drivers/emWin_Config/: GUI_X_Touch_Analog.c GUIConf.c lcd_ssd1289.c LCDConf.c timer5.c TOUCH_Calibrate.c TOUCH_Sample.c touch_spi.c
  group emWin_Demo
    ../../drivers/emWin_Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group emWin_library
    ../../Libraries/STemWinLibrary522/OS/: GUI_X.c
    ../../Libraries/STemWinLibrary522/Lib/: STemWin522_CM3_IAR.a
  group Filesystem
    ../../../RT-Thread_1.2.1/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../RT-Thread_1.2.1/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../../../RT-Thread_1.2.1/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Kernel
    ../../../RT-Thread_1.2.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group STM32_StdPeriph
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
