# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\RT-THREAD\components\CMSIS\Include;..\..\drivers;applications;.;..\..\..\RT-THREAD\include;..\..\..\RT-THREAD\libcpu\arm\cortex-m3;..\..\..\RT-THREAD\libcpu\arm\common;..\..\..\RT-THREAD\components\net\lwip-1.4.1\src;..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\include;..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\arch\include;..\..\..\RT-THREAD\components\net\lwip-1.4.1\src\include\netif;..\..\..\RT-THREAD\components\net\freemodbus-v1.6.0\modbus\include;..\..\..\RT-THREAD\components\net\freemodbus-v1.6.0\modbus\rtu;..\..\..\RT-THREAD\components\net\freemodbus-v1.6.0\modbus\ascii;..\..\..\RT-THREAD\components\net\freemodbus-v1.6.0\modbus\tcp;..\..\..\RT-THREAD\components\net\freemodbus-v1.6.0\modbus\port;..\..\..\RT-THREAD\components\finsh;..\..\..\RT-THREAD\components\drivers\spi;..\..\..\RT-THREAD\components\drivers\include;..\..\..\RT-THREAD\components\dfs\include;..\..\..\RT-THREAD\components\dfs\filesystems\elmfat
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group STM32_StdPeriph
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Drivers
    ../../drivers/: CommonString.c GPRSIO.c I2C.c RS485.c RTC.c adc.c board.c calendar.c can.c candevice.c date.c gprs.c i2c_ee_dma.c key.c led.c msd.c platform.c rt_stm32f10x_spi.c serial.c spi_flash.c stm32_eth.c stm32f10x_it.c usart.c
  group Applications
    applications/: application.c mbtest.c startup.c
  group Kernel
    ../../../RT-THREAD/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../../RT-THREAD/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../../RT-THREAD/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group LwIP
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../RT-THREAD/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group FreeModbus
    ../../../RT-THREAD/components/net/freemodbus-v1.6.0/modbus/functions/: mbfuncdiag.c mbutils.c mbfuncother.c mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c
    ../../../RT-THREAD/components/net/freemodbus-v1.6.0/modbus/rtu/: mbcrc.c
    ../../../RT-THREAD/components/net/freemodbus-v1.6.0/modbus/port/: port.c portevent.c porttcp.c
    ../../../RT-THREAD/components/net/freemodbus-v1.6.0/modbus/: mb.c
    ../../../RT-THREAD/components/net/freemodbus-v1.6.0/modbus/tcp/: mbtcp.c
  group finsh
    ../../../RT-THREAD/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group DeviceDrivers
    ../../../RT-THREAD/components/drivers/spi/: spi_core.c spi_dev.c
  group Filesystem
    ../../../RT-THREAD/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../RT-THREAD/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
